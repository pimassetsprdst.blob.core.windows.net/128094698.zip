Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-07-26T11:29:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jul 26 11:29:52 2018 * Host: B3ROBRAWR2782 * Database: C:\Users\VM\AppData\Local\Temp\{722CAAF0-03EE-41C9-8DFE-8903E619E86B}\ifc * Database version: 5507 * Database creation date: Thu Jul 26 11:29:50 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu Jul 26 11:29:51 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jul 26 11:29:51 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Design Option: Main Model; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcDistributionControlElement: 6818 U-500, E_Detector_Movement_MEPcontent_ABB_Presence Detector Corridor_INT-EN:6818 U-500:1329499
In: V00
Type - PredefinedType: MOVEMENTSENSOR; Material: Color RGB 224-235-234, Color RAL 9010
Type - Dimensions - Depth: 101.5 mm; Diameter: 110 mm; Rotation U-Axis Correction: 0 deg; Rotation V-Axis Correction: 0 deg; Rotation W-Axis Correction: 0 deg
Type - Electrical - App ID: EL_MODELPARTSYSTEM_MC; Hertz: 50 Hz
Type - Electrical - Loads - Voltage: 230 V
Type - Identity Data - Article Description: Busch-Watchdog Presence tech BasicLINE Corridor; Article Type: 6818 U-500; Category: EL_SINGLEPOLESWITCH; Content Supplier URL: www.mepcontent.com; Copyright: ©Stabiplan International BV; Custom: no; Description: Busch-Watchdog Presence tech BasicLINE Corridor; EMCS Version: 3.0; ETIM Article Class: EC000133; Family Version: 11.15; GTIN: 4011395148051; Manufacturer: ABB; Manufacturer Art. No.: 2CKA006800A2519; Manufacturer URL: http://new.abb.com/products/2CKA006800A2519/; MEPcontent Class: DETECTOR_MOVEMENT; Model: 6818 U-500; OmniClass Number: 23.85.30.14.14; OmniClass Title: Movement/Vibration Detection; Product Line: ABB; Revit Version: 2017; Type Name: 6818 U-500; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Other - Category: Security Devices; Family Name: E_Detector_Movement_MEPcontent_ABB_Presence Detector Corridor_INT-EN
Pset_ManufacturerTypeInformation - Manufacturer: ABB
Constraints - Annotation Offset: 0 mm; Annotation Offset RL: 0 mm; Offset: 0 mm
Dimensions - Area: 39.2004 m2; FOD Area: 6000 mm; FOD Height: 3000 mm; Rotation U-Axis: 0 deg; Rotation V-Axis: 0 deg; Rotation W-Axis: 0 deg; Volume: 0.000409938 m3
Electrical - Loads - Power: 0 W
Identity Data - Design Option: Main Model; Function Code: E6311; Mark: 1
Other - Offset: 0 mm; Family: E_Detector_Movement_MEPcontent_ABB_Presence Detector Corridor_INT-EN: 6818 U-500; Family and Type: E_Detector_Movement_MEPcontent_ABB_Presence Detector Corridor_INT-EN: 6818 U-500; FOD Diameter Safe: 6500 mm; Type: E_Detector_Movement_MEPcontent_ABB_Presence Detector Corridor_INT-EN: 6818 U-500; Type Id: E_Detector_Movement_MEPcontent_ABB_Presence Detector Corridor_INT-EN: 6818 U-500
Phasing - Phase Created: 4. Plan over 10 years
Visibility - FOD Visibility: no; Mounting Box: no; Protective Cage: no
